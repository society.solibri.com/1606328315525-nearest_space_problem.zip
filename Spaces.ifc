Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: P294-PROJ-PC-CutBox.ifc (Edited by Simplebim 8.2 SR1 - Evaluation)
Time: 2020-10-27T19:45:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191031_1115(x64) - Exporter 20.2.0.48 - Alternate UI 20.2.0.48

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (m)
P00 | P00 | 0
P01 | P01 | 3.93
